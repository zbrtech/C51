# Keil uVision project key.uvproj, settings and files
target 目标 1 (MCS-51)
  device: T80C51 Atmel
  cpu: IRAM(0 - 0x7F) IROM(0 - 0xFFF) CLOCK(44000000)
  output: key +hex
  c flags: Optimize=8 SizeSpeed=1
  group 源组 1
    ./: main.c
